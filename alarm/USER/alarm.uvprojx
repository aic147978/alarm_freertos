# Keil uVision project alarm.uvprojx, settings and files
target alarm (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: alarm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\DHT11;..\HARDWARE\KEY;..\HARDWARE\PCF8574;..\HARDWARE\RS485;..\HARDWARE\IIC;..\HARDWARE\zmpt101b;..\HARDWARE\ADC;..\HARDWARE\easyUI;..\HARDWARE\lcd;..\HARDWARE\touch;..\HARDWARE\24CXX;..\HARDWARE\SDRAM;..\HARDWARE\W25QXX;..\HARDWARE\SDIO;..\HARDWARE\NAND;..\FATFS\src;..\FATFS\exfuns;..\MALLOC;..\TEXT;..\HARDWARE\SPI;..\HARDWARE\RTC;..\USMART;..\HARDWARE\esp8266driver;..\MIddlewares\FreeRTOS;..\MIddlewares\FreeRTOS\portable\MemMang;..\MIddlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\MIddlewares\FreeRTOS\include;..\MIddlewares\midware
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../MIddlewares/midware/: midware.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/zmpt101b/: zmpt101b.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/easyUI/: easyUI.c
    ../HARDWARE/lcd/: lcd.c ltdc.c
    ../HARDWARE/touch/: ctiic.c ft5206.c touch.c gt9147.c gt9271.c ott2001a.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/NAND/: ftl.c nand.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/esp8266driver/: dwt_stm32_delay.c ESP8266.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group FATFS
    ../FATFS/exfuns/: mycc936.c exfuns.c
    ../FATFS/src/: diskio.c ff.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group Middlewares/FreeRTOS_PORT
    ../MIddlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../MIddlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS_CORE
    ../MIddlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
